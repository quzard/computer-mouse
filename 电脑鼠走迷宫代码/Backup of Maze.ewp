# IAR project Backup of Maze.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8n.h
  General.OGChipSelectEditMenu: LM3S615 Luminary LM3S615
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\Luminary
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk_LM3.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group lib
    $EW_DIR$/arm/lib/Luminary/: driverlib.r79
  group src
    src/: maze.c Maze.h Mouse_Drive.c Mouse_Drive.h zlg7289.c
  group startup
    src/: startup.c
